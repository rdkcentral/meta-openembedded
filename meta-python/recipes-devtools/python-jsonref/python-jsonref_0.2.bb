inherit setuptools
require python-jsonref.inc