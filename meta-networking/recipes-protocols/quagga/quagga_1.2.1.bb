# Copyright (C) 2018
# Author : Livin Sunny <livin_sunny2@comcast.com>

require quagga.inc

PR = "${INC_PR}.0"

SRC_URI[quagga-1.2.1.md5sum] = "b1546de89062f7070d56e780b30be4b1"
SRC_URI[quagga-1.2.1.sha256sum] = "aaddba5d4f41ed8e4c2f155f4584c993465d122c9096b5b52ada3fc75266fbcd"
